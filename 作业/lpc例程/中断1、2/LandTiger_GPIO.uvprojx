# Keil uVision project LandTiger_GPIO.uvprojx, settings and files
target LandTiger_GPIO (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LandTiger_GPIO +hex
  c flags: Optim=1
  c include: .\Source\CMSIS\startup\arm;.\Source\CMSIS;.\Source\APP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./Source/CMSIS/startup/arm/: startup_LPC17xx.s
    ./Source/CMSIS/: core_cm3.c system_LPC17xx.c
  group APP
    ./Source/APP/: main.c
    ../../../资料/DiscoveryQ2光盘资料/DiscoveryQ2光盘资料/ULM1超声测距模块/App/: my_bsp.c
  group DOC
    ./Source/: readme.txt
software components: CMSIS:CORE 4.1.0
